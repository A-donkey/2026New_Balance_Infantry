# Keil uVision project Cboard.uvprojx, settings and files
target Cboard (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: Cboard +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,ARM_MATH_CM4,__TARGET_FPU_VFP,__CC_ARM
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Bsp/Inc;../External_Device/BMI088/Inc;../Task/Inc;../Math/Inc;../External_Device/BMI088/Controller/Inc;../Controller/Inc;../Motor/Inc;../APP/Inc;../Judge/Src;../Judge/Inc;../Parameter_Tree;..\Config
  asm include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User
    ../Src/: main.c gpio.c freertos.c can.c crc.c dma.c i2c.c spi.c tim.c usart.c usb_device.c usbd_conf.c usbd_desc.c usbd_cdc_if.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_can.c stm32f4xx_hal_crc.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group External_Device/BMI088
    ../External_Device/BMI088/Src/: BMI088driver.c BMI088Middleware.c
    ../External_Device/BMI088/Inc/: BMI088driver.h BMI088Middleware.h BMI088reg.h
  group Controller
    ../Controller/Src/: PID.c LQR.c
    ../Controller/Inc/: PID.h LQR.h
  group Task
    ../Task/Src/: Ins_Task.c Ref_Task.c Check_Task.c Chassis_Task.c Super_Cap_Task.c Board_Can_Task.c
    ../Task/Inc/: Ins_Task.h Ref_Task.h Check_Task.h Chassis_Task.h Super_Cap_Task.h Board_Can_Task.h
  group Math
    ../Math/Src/: user_lib.c kalman_filter.c wheel_kalman.c QuaternionEKF.c
    ../Math/Inc/: user_lib.h kalman_filter.h wheel_kalman.h QuaternionEKF.h
  group Motor
    ../Motor/Src/: Dji_Motor.c Damiao_Motor.c
    ../Motor/Inc/: Dji_Motor.h Damiao_Motor.h
  group Bsp
    ../Bsp/Src/: bsp_rc.c bsp_dwt.c bsp_can.c bsp_PWM.c bsp_buzzer.c
    ../Bsp/Inc/: bsp_rc.h bsp_dwt.h bsp_can.h bsp_PWM.h bsp_buzzer.h
  group App
    ../APP/Src/: VT03.c Vofa.c VMC.c Super_Cap.c Buzzer_Run.c Self_Rescue.c Can_Feedback.c Remote_Control.c Some_Functions.c Power_Limit.c
    ../APP/Inc/: VT03.h Vofa.h VMC.h Super_Cap.h Buzzer_Run.h Self_Rescue.h Can_Feedback.h Remote_Control.h Some_Functions.h Power_Limit.h
  group Judge
    ../Judge/Src/: fifo.c CRCs.c Referee.c
  group Parameter
    ../Parameter_Tree/: Parameter.h
  group Config
    ../Config/: can_config.h
software components: CMSIS:CORE 6.1.1, CMSIS:DSP 1.16.2
